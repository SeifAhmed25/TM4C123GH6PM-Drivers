# Keil uVision project SimpleSchedularOS_TM4C123GH6PM.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SimpleSchedularOS_TM4C123GH6PM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\COTS\MCAL;.\COTS\MCAL\DIO\Inc;.\COTS\MCAL\IntCtrl\Inc;.\COTS\MCAL\PORT\Inc;.\COTS\MCAL\Systick\Inc;.\COTS\CONFIG;.\COTS\LIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../../../ARM/3- Video/2-  Systick/CODE/COTS/APP/: main.c
  group MCAL
    ../../../ARM/3- Video/2-  Systick/CODE/COTS/MCAL/DIO/: Dio_prg.c
    ../../../ARM/3- Video/2-  Systick/CODE/COTS/MCAL/IntCtrl/: IntCtrl_prg.c
    ../../../ARM/3- Video/2-  Systick/CODE/COTS/MCAL/PORT/: Port_prg.c
    ../../../ARM/3- Video/2-  Systick/CODE/COTS/MCAL/Systick/: Systick_prg.c
  group CONFIG
    ../../../ARM/3- Video/2-  Systick/CODE/COTS/CONFIG/: IntCtrl_Lcfg.c Port_Lcfg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
